require linux-yocto-nxp-imx9.inc

KBRANCH:nxp-imx9  = "v6.6/standard/preempt-rt/nxp-sdk-6.6/nxp-soc"
