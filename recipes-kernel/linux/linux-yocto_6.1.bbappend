require linux-yocto-nxp-imx9.inc

KBRANCH:nxp-imx9  = "v6.1/standard/nxp-sdk-6.1/nxp-soc"
