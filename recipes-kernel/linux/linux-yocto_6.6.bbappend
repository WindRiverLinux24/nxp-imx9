require linux-yocto-nxp-imx9.inc

KBRANCH:nxp-imx9  = "v6.6/standard/nxp-sdk-6.6/nxp-soc"
